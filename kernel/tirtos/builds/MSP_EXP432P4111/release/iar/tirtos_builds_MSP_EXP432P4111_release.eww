<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/tirtos_builds_MSP_EXP432P4111_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
