# IAR project dma_eusci_spi_scatter_gather_MSP_EXP432P4111_nortos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  group (top)
    ./: dma_eusci_spi_scatter_gather_MSP_EXP432P4111_nortos_iar.ipcf
