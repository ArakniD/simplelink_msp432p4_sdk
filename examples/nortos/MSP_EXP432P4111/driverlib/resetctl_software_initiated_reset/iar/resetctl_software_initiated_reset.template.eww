<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/resetctl_software_initiated_reset.ewp</path>
  </project>
  <batchBuild/>
</workspace>
