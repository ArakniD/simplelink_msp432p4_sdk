# IAR project crc32_32-bit_signature_calculation_MSP_EXP432P4111_nortos_iar.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  group (top)
    ./: crc32_32-bit_signature_calculation_MSP_EXP432P4111_nortos_iar.ipcf
