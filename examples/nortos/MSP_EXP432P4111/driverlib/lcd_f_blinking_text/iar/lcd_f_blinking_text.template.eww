<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/lcd_f_blinking_text.ewp</path>
  </project>
  <batchBuild/>
</workspace>
