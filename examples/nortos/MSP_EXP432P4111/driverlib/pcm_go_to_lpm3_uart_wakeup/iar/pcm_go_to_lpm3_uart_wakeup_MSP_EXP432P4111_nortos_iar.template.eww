<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/pcm_go_to_lpm3_uart_wakeup_MSP_EXP432P4111_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>