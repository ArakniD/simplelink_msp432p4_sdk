<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/sysctl_a_disable_sram_bank_MSP_EXP432P4111_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>