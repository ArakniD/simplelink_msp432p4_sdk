<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/flash_a_program_memory_MSP_EXP432P4111_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>