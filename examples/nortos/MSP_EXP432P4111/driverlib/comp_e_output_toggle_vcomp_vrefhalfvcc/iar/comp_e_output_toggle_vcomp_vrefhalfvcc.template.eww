<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/comp_e_output_toggle_vcomp_vrefhalfvcc.ewp</path>
  </project>
  <batchBuild/>
</workspace>
