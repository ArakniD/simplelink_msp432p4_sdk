<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/timer_a_continuous_vlo_period_capture.ewp</path>
  </project>
  <batchBuild/>
</workspace>
