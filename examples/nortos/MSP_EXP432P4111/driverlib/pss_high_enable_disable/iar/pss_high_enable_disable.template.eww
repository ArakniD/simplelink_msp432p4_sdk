<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/pss_high_enable_disable.ewp</path>
  </project>
  <batchBuild/>
</workspace>
