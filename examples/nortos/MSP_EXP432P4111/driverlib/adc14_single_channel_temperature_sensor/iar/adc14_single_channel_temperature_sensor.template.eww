<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/adc14_single_channel_temperature_sensor.ewp</path>
  </project>
  <batchBuild/>
</workspace>
