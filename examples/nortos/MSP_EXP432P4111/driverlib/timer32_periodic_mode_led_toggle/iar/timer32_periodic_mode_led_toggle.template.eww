<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/timer32_periodic_mode_led_toggle.ewp</path>
  </project>
  <batchBuild/>
</workspace>
