<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/comp_e_interrupt_output_toggle_vref12v.ewp</path>
  </project>
  <batchBuild/>
</workspace>
