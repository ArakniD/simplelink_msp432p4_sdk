# Keil uVision project flash_a_nonblocking_erase.uvprojx, settings and files
target flash_a_nonblocking_erase (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MSP432P4111 Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.1.0_Falcon2M
  cpu: IROM(0x00000000,0x200000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: flash_a_nonblocking_erase
  AfterMake: fromelf --bin --output .\Build\flash_a_nonblocking_erase.bin .\Build\flash_a_nonblocking_erase.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P4111__
  c include: ../../../../../../source ; ../../../../../../source/third_party/CMSIS/Include/
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x1000000 size 0x40000
  group Source
    ../: flash_a_nonblocking_erase.c system_msp432p4111.c
    ./: startup_msp432p4111_uvision.s
  group Library
    ../../../../../../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
software components: CMSIS:CORE 4.3.0
