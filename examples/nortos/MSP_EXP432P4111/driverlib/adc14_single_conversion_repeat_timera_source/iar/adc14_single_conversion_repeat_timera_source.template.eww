<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/adc14_single_conversion_repeat_timera_source.ewp</path>
  </project>
  <batchBuild/>
</workspace>
