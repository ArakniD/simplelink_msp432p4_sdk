<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/dma_aes256_ecb_encrypt_decrypt.ewp</path>
  </project>
  <batchBuild/>
</workspace>
