<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/msp432p401x_euscib0_i2c_master_multislave.ewp</path>
  </project>
  <batchBuild/>
</workspace>
