<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/msp432p401x_ta0_08_MSP_EXP432P401R_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>