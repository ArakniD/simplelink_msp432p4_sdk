<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/msp432p401x_rtc_lpm35_01.ewp</path>
  </project>
  <batchBuild/>
</workspace>
