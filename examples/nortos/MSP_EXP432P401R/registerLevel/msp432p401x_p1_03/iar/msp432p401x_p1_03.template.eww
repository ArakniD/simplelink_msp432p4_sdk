<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/msp432p401x_p1_03.ewp</path>
  </project>
  <batchBuild/>
</workspace>
