# Keil uVision project cmsis_dsplib_ulp.uvprojx, settings and files
target cmsis_dsplib_ulp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cmsis_dsplib_ulp
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4, __FPU_PRESENT=1, __MSP432P401R__, DeviceFamily_MSP432P401Rx
  c include: ..\..\..\..\..\..\source;..\..\..\..\..\..\source\third_party\CMSIS\Include;..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  scatter file: .\msp432p401r_LPM.sct
  group Source Group 1
    ../: dmaTasks.c main.c system_msp432p401r.c dmaTasks.h main.h preCompile.h
    ./: startup_msp432p401r_uvision.s
  group Libraries
    ../../../../../../source/third_party/CMSIS/DSP_Lib/lib/keil/m4f/: arm_cortexM4lf_math.a
    ../../../../../../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
