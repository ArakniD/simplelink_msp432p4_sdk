<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/boostxl_sensors_sensorgui_msp432p401r.ewp</path>
  </project>
  <batchBuild/>
</workspace>
