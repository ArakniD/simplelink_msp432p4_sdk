<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/uart_pc_echo_12mhz_brclk.ewp</path>
  </project>
  <batchBuild/>
</workspace>
