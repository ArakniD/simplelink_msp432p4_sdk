<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/adc14_multiple_channel_no_repeat.ewp</path>
  </project>
  <batchBuild/>
</workspace>
