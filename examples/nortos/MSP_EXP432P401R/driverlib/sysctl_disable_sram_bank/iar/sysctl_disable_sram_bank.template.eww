<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/sysctl_disable_sram_bank.ewp</path>
  </project>
  <batchBuild/>
</workspace>
