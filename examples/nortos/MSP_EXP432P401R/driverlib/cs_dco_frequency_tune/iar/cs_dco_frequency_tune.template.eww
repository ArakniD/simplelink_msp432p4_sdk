<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/cs_dco_frequency_tune.ewp</path>
  </project>
  <batchBuild/>
</workspace>
