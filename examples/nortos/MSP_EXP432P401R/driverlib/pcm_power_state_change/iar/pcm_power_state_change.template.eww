<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/pcm_power_state_change.ewp</path>
  </project>
  <batchBuild/>
</workspace>
