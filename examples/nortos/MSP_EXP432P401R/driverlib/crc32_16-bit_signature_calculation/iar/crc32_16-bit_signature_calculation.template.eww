<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/crc32_16-bit_signature_calculation.ewp</path>
  </project>
  <batchBuild/>
</workspace>
