<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/timer_a_updown_compare_multiple_pwm.ewp</path>
  </project>
  <batchBuild/>
</workspace>
