# IAR project comp_e_interrupt_output_toggle_vref12v_MSP_EXP432P401R_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: comp_e_interrupt_output_toggle_vref12v_MSP_EXP432P401R_nortos_iar.ipcf
