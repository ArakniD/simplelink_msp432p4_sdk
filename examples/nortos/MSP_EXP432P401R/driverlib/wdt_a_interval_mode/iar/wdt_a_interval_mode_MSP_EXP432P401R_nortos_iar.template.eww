<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/wdt_a_interval_mode_MSP_EXP432P401R_nortos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>