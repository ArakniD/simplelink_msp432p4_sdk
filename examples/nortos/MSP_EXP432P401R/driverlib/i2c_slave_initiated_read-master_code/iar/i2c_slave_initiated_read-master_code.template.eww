<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/i2c_slave_initiated_read-master_code.ewp</path>
  </project>
  <batchBuild/>
</workspace>
