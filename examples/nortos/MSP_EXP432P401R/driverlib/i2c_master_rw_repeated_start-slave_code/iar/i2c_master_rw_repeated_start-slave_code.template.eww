<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/i2c_master_rw_repeated_start-slave_code.ewp</path>
  </project>
  <batchBuild/>
</workspace>
