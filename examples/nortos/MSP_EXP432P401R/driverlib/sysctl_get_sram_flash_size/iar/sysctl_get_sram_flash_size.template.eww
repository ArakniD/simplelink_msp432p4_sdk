<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/sysctl_get_sram_flash_size.ewp</path>
  </project>
  <batchBuild/>
</workspace>
