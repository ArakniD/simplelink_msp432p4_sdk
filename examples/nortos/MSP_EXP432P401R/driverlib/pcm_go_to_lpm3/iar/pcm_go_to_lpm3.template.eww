<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/pcm_go_to_lpm3.ewp</path>
  </project>
  <batchBuild/>
</workspace>
