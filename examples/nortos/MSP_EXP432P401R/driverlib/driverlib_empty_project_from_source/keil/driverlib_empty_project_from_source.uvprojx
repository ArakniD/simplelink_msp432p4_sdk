# Keil uVision project driverlib_empty_project_from_source.uvprojx, settings and files
target driverlib_empty_project_from_source (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.3
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: driverlib_empty_project_from_source
  AfterMake: fromelf --bin --output .\Build\driverlib_empty_project_from_source.bin .\Build\driverlib_empty_project_from_source.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__
  c misc: --diag_suppress 1296
  c include: ../../../../../../source ; ../../../../../../source/third_party/CMSIS/Include/
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: main.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
  group DriverLib
    ../../../../../../source/ti/devices/msp432p4xx/driverlib/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c fpu.c gpio.c i2c.c interrupt.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c systick.c timer_a.c timer32.c uart.c wdt_a.c
software components: CMSIS:CORE 4.3.0
