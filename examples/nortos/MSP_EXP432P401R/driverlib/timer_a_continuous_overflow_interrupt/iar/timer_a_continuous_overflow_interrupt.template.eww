<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/timer_a_continuous_overflow_interrupt.ewp</path>
  </project>
  <batchBuild/>
</workspace>
