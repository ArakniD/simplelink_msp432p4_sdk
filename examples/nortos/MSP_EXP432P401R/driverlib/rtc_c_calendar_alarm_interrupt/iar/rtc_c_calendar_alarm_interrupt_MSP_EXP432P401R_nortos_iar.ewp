# IAR project rtc_c_calendar_alarm_interrupt_MSP_EXP432P401R_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: rtc_c_calendar_alarm_interrupt_MSP_EXP432P401R_nortos_iar.ipcf
