<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/cs_lfxt_start.ewp</path>
  </project>
  <batchBuild/>
</workspace>
