# Keil uVision project i2c_master_w_multibyte_multislave-master_code.uvprojx, settings and files
target i2c_master_w_multibyte_multislave-master_code (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.1.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: i2c_master_w_multibyte_multislave-master_code
  AfterMake: fromelf --bin --output .\Build\i2c_master_w_multibyte_multislave-master_code.bin .\Build\i2c_master_w_multibyte_multislave-master_code.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__
  c include: ../../../../../../source ; ../../../../../../source/third_party/CMSIS/Include/
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: i2c_master_w_multibyte_multislave-master_code.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
  group Library
    ../../../../../../source/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
software components: CMSIS:CORE 4.3.0
