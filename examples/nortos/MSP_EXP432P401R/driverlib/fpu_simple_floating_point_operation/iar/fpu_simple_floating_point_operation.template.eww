<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/fpu_simple_floating_point_operation.ewp</path>
  </project>
  <batchBuild/>
</workspace>
