<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/benchloop_MSP_EXP432P401R_tirtos_iar.ewp</path>
    </project>
    <batchBuild/>
</workspace>