# IAR project capturepwmdisplay_MSP_EXP432P401R_freertos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: capturepwmdisplay_MSP_EXP432P401R_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
