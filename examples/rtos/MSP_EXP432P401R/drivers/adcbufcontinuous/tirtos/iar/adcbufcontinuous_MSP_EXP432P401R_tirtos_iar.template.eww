<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/adcbufcontinuous_MSP_EXP432P401R_tirtos_iar.ewp</path>
    </project>
    <project>
        <path>$SIMPLELINK_MSP432_SDK_INSTALL_DIR$/kernel/tirtos/builds/MSP_EXP432P401R/release/iar/tirtos_builds_MSP_EXP432P401R_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>