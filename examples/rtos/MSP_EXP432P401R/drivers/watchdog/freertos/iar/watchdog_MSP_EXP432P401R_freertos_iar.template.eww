<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/watchdog_MSP_EXP432P401R_freertos_iar.ewp</path>
    </project>
    <project>
        <path>$SIMPLELINK_MSP432_SDK_INSTALL_DIR$/kernel/freertos/builds/MSP_EXP432P401R/release/iar/freertos_builds_MSP_EXP432P401R_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>