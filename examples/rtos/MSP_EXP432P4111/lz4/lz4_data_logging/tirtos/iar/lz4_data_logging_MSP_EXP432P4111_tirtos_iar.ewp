# IAR project lz4_data_logging_MSP_EXP432P4111_tirtos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: lz4_data_logging_MSP_EXP432P4111_tirtos_iar.ipcf
