<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$/lz4_data_logging_MSP_EXP432P4111_freertos_iar.ewp</path>
    </project>
    <project>
        <path>$SIMPLELINK_MSP432_SDK_INSTALL_DIR$/kernel/freertos/builds/MSP_EXP432P4111/release/iar/freertos_builds_MSP_EXP432P4111_release.ewp</path>
    </project>
    <batchBuild/>
</workspace>