# IAR project outofbox_msp432p4111_MSP_EXP432P4111_freertos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: outofbox_msp432p4111_MSP_EXP432P4111_freertos_iar.ipcf SysConfig_Generated_Files.ipcf
